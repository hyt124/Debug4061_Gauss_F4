# Keil uVision project Motor.uvprojx, settings and files
target Motor (6120000::V6.12::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Motor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;                       ../Drivers/STM32F4xx_HAL_Driver/Inc;                       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                       ../Drivers/CMSIS/Include;                       ..\Drivers\MOTOR\h;                       ..\MyFile;                       ..\MyFile
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group MOTOR
    ../Drivers/MOTOR/: motor.c
    ../Drivers/MOTOR/h/: motor.h
  group MyFIles
    ../MyFile/: FONT.h ILI93xx.c ILI93xx.h sys.h UserMain.c UserMain.h KeyPad.c KeyPad.h User_PID.c User_PID.h User_PWM.c User_PWM.h User_Uart.c User_Uart.h MricroStepDriver.c MricroStepDriver.h GaussGun.c GaussGun.h Timer.c Timer.h
software components: CMSIS:CORE 5.2.0
